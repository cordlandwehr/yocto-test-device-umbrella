PACKAGECONFIG_append += " \
    gbm \
    kms \
    eglfs \
"
