PACKAGECONFIG_append_raspberrypi4 = " \
    wayland-drm-egl-server-buffer \
"
